# Keil uVision project project.uvprojx, settings and files
target rt-thread (6190000::V6.19::ARMCLANG)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: __STDC_LIMIT_MACROS, RT_USING_ARMLIBC, USE_HAL_DRIVER, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__, STM32F429xx
  c include: packages\TinyUSB-v0.14.1\src;applications;..\..\..\components\libc\posix\ipc;..\libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Inc;..\..\..\components\libc\compilers\common\include;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\libraries\HAL_Drivers;..\libraries\HAL_Drivers\CMSIS\Include;..\..\..\components\libc\posix\io\stdio;..\..\..\components\drivers\include;packages\TinyUSB-v0.14.1\rt-thread;board\CubeMX_Config\Inc;..\..\..\components\libc\compilers\common\extension;..\..\..\libcpu\arm\cortex-m4;..\libraries\STM32F4xx_HAL\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\components\drivers\include;..\..\..\libcpu\arm\common;.;..\..\..\include;..\..\..\components\libc\posix\io\poll;..\..\..\components\finsh;board;..\..\..\components\drivers\include;..\libraries\HAL_Drivers\config;board\ports
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
  group CPU
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../../components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial.c
  group Drivers
    ../libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429xx.s
    board/CubeMX_Config/Src/: stm32f4xx_hal_msp.c
    board/: board.c
    ../libraries/HAL_Drivers/: drv_common.c drv_gpio.c drv_usart.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler_up.c thread.c timer.c
  group Libraries
    ../libraries/STM32F4xx_HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_hcd.c stm32f4xx_ll_usb.c stm32f4xx_hal_pccard.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_usart.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_cortex.c stm32f4xx_hal_cryp.c stm32f4xx_hal.c stm32f4xx_hal_cec.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_gpio.c
    ../libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group TinyUSB
    packages/TinyUSB-v0.14.1/src/class/cdc/: cdc_device.c
    packages/TinyUSB-v0.14.1/src/device/: usbd.c usbd_control.c
    packages/TinyUSB-v0.14.1/src/portable/synopsys/dwc2/: dcd_dwc2.c
    packages/TinyUSB-v0.14.1/rt-thread/: usb_descriptor.c tinyusb_port.c
    packages/TinyUSB-v0.14.1/rt-thread/bsp/stm32/: drv_tinyusb.c
    packages/TinyUSB-v0.14.1/src/class/hid/: hid_device.c
    packages/TinyUSB-v0.14.1/src/: tusb.c
    packages/TinyUSB-v0.14.1/rt-thread/port/: hid_device_port.c
    packages/TinyUSB-v0.14.1/src/portable/st/stm32_fsdev/: dcd_stm32_fsdev.c
    packages/TinyUSB-v0.14.1/src/common/: tusb_fifo.c
